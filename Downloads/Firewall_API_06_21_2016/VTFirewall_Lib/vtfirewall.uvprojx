# Keil uVision project vtfirewall.uvprojx, settings and files
target VTFirewallLib (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F107RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: vtfirewall (library)
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\src\Firewall;.\src\Malloc;.\src\FILES;.\src\FATS
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./src/Firewall/: fw_private.c
