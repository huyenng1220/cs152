# Keil uVision project VTFirewall.uvprojx, settings and files
target VTFirewall_Test (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F105RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: VTFirewall +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_CL, USE_STDPERIPH_DRIVER
  c include: .\src\eeprom;.\src\Test;.\src;.\src\CAN;.\src\STMLib\StdPeriph_Driver\inc;.\src\STMLib\System;.\src\UART;..\VTFirewall_Lib2\src
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group src
    ./src/CAN/: can_2.c can_1.c can_queue.c
    ./src/: main.c
    ./src/UART/: Retaget.c serial.c
  group StdPeriph_Drive
    ./src/STMLib/StdPeriph_Driver/src/: stm32f10x_rcc.c misc.c stm32f10x_can.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_usart.c
  group CMSIS
    ./src/STMLib/System/: core_cm3.c system_stm32f10x.c
    ./src/STMLib/Startup/: startup_stm32f10x_cl.s
  group VTFirewallLib
    ../VTFirewall_Lib2/Objects/: VTFirewallLib2.lib
  group Test
    ./src/eeprom/: eeprom.c
    ./src/: file.c
    ./src/Test/: test_firewall_functions.c
